# Keil uVision project Test_Package_Driver_IMU.uvprojx, settings and files
target Test_Package_Driver_IMU (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1
  c define: ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,
  c include: .\;..\..\..\1_Processor\STM32F4\Start_Code;..\..\..\1_Processor\STM32F4\Start_Code\CMSIS;..\..\..\1_Processor\STM32F4\Start_Code\FWlib\inc;..\..\..\1_Processor\STM32F4\BSP;..\..\..\2_Package\Driver_IMU;..\..\..\1_Processor\ARM_Libraries\DSP_Lib\Lib;..\..\..\1_Processor\ARM_Libraries\DSP_Lib\Include;..\..\..\2_Package\LIB_Math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp main_includes.h main_config.h stm32f4xx_it.cpp
  group Start_Code
    ../../../1_Processor/STM32F4/Start_Code/: stm32f4xx_conf.h
    ../../../1_Processor/STM32F4/Start_Code/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
    ../../../1_Processor/STM32F4/Start_Code/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ../../../1_Processor/STM32F4/BSP/: BSP_TOP.c BSP_TOP.h nvic.c nvic.h delay.c delay.h rtc.c rtc.h wdg_wkup.c wdg_wkup.h flash.c flash.h led_key.c led_key.h usart.c usart.h adc_dac.c adc_dac.h timer.c timer.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h encoder.c encoder.h i2c.c i2c.h can.c can.h spi.c spi.h
  group ARM_LIB/DSP/Lib
    ../../../1_Processor/ARM_Libraries/DSP_Lib/Lib/: arm_cortexM4lf_math.lib
  group Package/LIB_Math
    ../../../2_Package/LIB_Math/: base_math_config.h base_math_top.cpp base_math_top.h base_math_matrix.cpp base_math_matrix.h base_math_trigonometric.cpp base_math_trigonometric.h
  group Package/Driver_IMU
    ../../../2_Package/Driver_IMU/: imu_config.h imu_top.cpp imu_top.h imu_top_arithmetic_model.cpp imu_top_arithmetic_model.h imu_arithmetic_kalman.cpp imu_arithmetic_kalman.h imu_gps_driver.cpp imu_gps_driver.h imu_bmp085_driver.cpp imu_bmp085_driver.h imu_hmc5883l_driver.cpp imu_hmc5883l_driver.h imu_mpu6050_driver.cpp imu_mpu6050_driver.h
